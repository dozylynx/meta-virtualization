require xen.inc
require xen-version.inc
require xen-tools.inc
